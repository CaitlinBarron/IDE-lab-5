# Keil uVision project part1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MK64FX512xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: part1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: main.c uart.c MK64F12.h uart.h camera_FTM_blank.c main_A2D_template.c isr.h isr.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
